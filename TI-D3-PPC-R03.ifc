Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: TI-D3-PPC-R03.ifc
Time: 2026-10-17T00:00:00
Author: Traffic Industries
Organization: Traffic Industries
Written by: ifcopenshell 0.8.4
Made in: Source-preserving D3 R03 reference export

# IfcBuildingElementProxy: Current R03 native physical occurrence (5)
In: Product reference coordinates
PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-D3-PPC-R03; Revision: R03; SourceNativeSHA256: f5e398b591e95a851926d771abd048272929b1e68bb04d3ea779658a267822a0; PhysicalOccurrences: 5: one final body and four optical instances; UseBoundary: Current own-design nominal reference; no manufacturing tolerance, material grade, actual optical performance or load certification; SourceAppearance: RGB not documented in native source; neutral reference RGB8=166/166/166; Unit: mm
Name | Description
PocketedBody3 | TI-D3-PPC-R03 body
OpticInstance0 | OpticInstance0
OpticInstance1 | OpticInstance1
OpticInstance2 | OpticInstance2
OpticInstance3 | OpticInstance3

# IfcElementAssembly: Passive road stud body and four optical elements, TI-D3-PPC-R03
In: Product reference coordinates
PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-D3-PPC-R03; Revision: R03; SourceNativeSHA256: f5e398b591e95a851926d771abd048272929b1e68bb04d3ea779658a267822a0; PhysicalOccurrences: 5: one final body and four optical instances; UseBoundary: Current own-design nominal reference; no manufacturing tolerance, material grade, actual optical performance or load certification; SourceAppearance: RGB not documented in native source; neutral reference RGB8=166/166/166; Unit: mm
