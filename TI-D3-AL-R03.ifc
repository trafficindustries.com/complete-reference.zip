Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: TI-D3-AL-R03.ifc
Time: 2026-10-17T00:00:00
Author: Traffic Industries
Organization: Traffic Industries
Written by: ifcopenshell 0.8.4
Made in: Source-preserving D3 R03 reference export

# IfcBuildingElementProxy: Current R03 native physical occurrence (5)
In: Product reference coordinates
PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-D3-AL-R03; Revision: R03; SourceNativeSHA256: 62b5bb372ddbc15cb42694a174392239f5cbab7ebf8e559093c9b4d41bb9f6e1; PhysicalOccurrences: 5: one final body and four optical instances; UseBoundary: Current own-design nominal reference; no manufacturing tolerance, material grade, actual optical performance or load certification; SourceAppearance: RGB not documented in native source; neutral reference RGB8=166/166/166; Unit: mm
Name | Description
PocketedBody3 | TI-D3-AL-R03 body
OpticInstance0 | OpticInstance0
OpticInstance1 | OpticInstance1
OpticInstance2 | OpticInstance2
OpticInstance3 | OpticInstance3

# IfcElementAssembly: Passive road stud body and four optical elements, TI-D3-AL-R03
In: Product reference coordinates
PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-D3-AL-R03; Revision: R03; SourceNativeSHA256: 62b5bb372ddbc15cb42694a174392239f5cbab7ebf8e559093c9b4d41bb9f6e1; PhysicalOccurrences: 5: one final body and four optical instances; UseBoundary: Current own-design nominal reference; no manufacturing tolerance, material grade, actual optical performance or load certification; SourceAppearance: RGB not documented in native source; neutral reference RGB8=166/166/166; Unit: mm
