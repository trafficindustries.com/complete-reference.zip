Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
Time: 2026-10-17T07:29:45
Written by: IfcOpenShell 0.8.0
Made in: IfcOpenShell 0.8.0

# IfcBuildingElementProxy: Physical source occurrence (4)
In: Reference coordinates
PredefinedType: USERDEFINED
Name | Description
BlackBase | STEP solid index 0
OrangeHollowBody | STEP solid index 1
WhiteFilm1 | STEP solid index 2
WhiteFilm2 | STEP solid index 3

# IfcElementAssembly: Source-native physical solid occurrences, C1_single nominal design reference DEV01
In: Reference coordinates
Description: Nominal design reference; manufacturing tolerances, material grades and ground-specific fixings not established; PredefinedType: USERDEFINED
