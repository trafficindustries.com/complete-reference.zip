Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
Time: 2026-10-17T07:31:31
Written by: IfcOpenShell 0.8.0
Made in: IfcOpenShell 0.8.0

# IfcBuildingElementProxy: Physical source occurrence (155)
In: Reference coordinates
PredefinedType: USERDEFINED
Name | Description
AssemblySolid_000 | STEP solid index 0
AssemblySolid_001 | STEP solid index 1
AssemblySolid_002 | STEP solid index 2
AssemblySolid_003 | STEP solid index 3
AssemblySolid_004 | STEP solid index 4
AssemblySolid_005 | STEP solid index 5
AssemblySolid_006 | STEP solid index 6
AssemblySolid_007 | STEP solid index 7
AssemblySolid_008 | STEP solid index 8
AssemblySolid_009 | STEP solid index 9
AssemblySolid_010 | STEP solid index 10
AssemblySolid_011 | STEP solid index 11
AssemblySolid_012 | STEP solid index 12
AssemblySolid_013 | STEP solid index 13
AssemblySolid_014 | STEP solid index 14
AssemblySolid_015 | STEP solid index 15
AssemblySolid_016 | STEP solid index 16
AssemblySolid_017 | STEP solid index 17
AssemblySolid_018 | STEP solid index 18
AssemblySolid_019 | STEP solid index 19
AssemblySolid_020 | STEP solid index 20
AssemblySolid_021 | STEP solid index 21
AssemblySolid_022 | STEP solid index 22
AssemblySolid_023 | STEP solid index 23
AssemblySolid_024 | STEP solid index 24
AssemblySolid_025 | STEP solid index 25
AssemblySolid_026 | STEP solid index 26
AssemblySolid_027 | STEP solid index 27
AssemblySolid_028 | STEP solid index 28
AssemblySolid_029 | STEP solid index 29
AssemblySolid_030 | STEP solid index 30
AssemblySolid_031 | STEP solid index 31
AssemblySolid_032 | STEP solid index 32
AssemblySolid_033 | STEP solid index 33
AssemblySolid_034 | STEP solid index 34
AssemblySolid_035 | STEP solid index 35
AssemblySolid_036 | STEP solid index 36
AssemblySolid_037 | STEP solid index 37
AssemblySolid_038 | STEP solid index 38
AssemblySolid_039 | STEP solid index 39
AssemblySolid_040 | STEP solid index 40
AssemblySolid_041 | STEP solid index 41
AssemblySolid_042 | STEP solid index 42
AssemblySolid_043 | STEP solid index 43
AssemblySolid_044 | STEP solid index 44
AssemblySolid_045 | STEP solid index 45
AssemblySolid_046 | STEP solid index 46
AssemblySolid_047 | STEP solid index 47
AssemblySolid_048 | STEP solid index 48
AssemblySolid_049 | STEP solid index 49
AssemblySolid_050 | STEP solid index 50
AssemblySolid_051 | STEP solid index 51
AssemblySolid_052 | STEP solid index 52
AssemblySolid_053 | STEP solid index 53
AssemblySolid_054 | STEP solid index 54
AssemblySolid_055 | STEP solid index 55
AssemblySolid_056 | STEP solid index 56
AssemblySolid_057 | STEP solid index 57
AssemblySolid_058 | STEP solid index 58
AssemblySolid_059 | STEP solid index 59
AssemblySolid_060 | STEP solid index 60
AssemblySolid_061 | STEP solid index 61
AssemblySolid_062 | STEP solid index 62
AssemblySolid_063 | STEP solid index 63
AssemblySolid_064 | STEP solid index 64
AssemblySolid_065 | STEP solid index 65
AssemblySolid_066 | STEP solid index 66
AssemblySolid_067 | STEP solid index 67
AssemblySolid_068 | STEP solid index 68
AssemblySolid_069 | STEP solid index 69
AssemblySolid_070 | STEP solid index 70
AssemblySolid_071 | STEP solid index 71
AssemblySolid_072 | STEP solid index 72
AssemblySolid_073 | STEP solid index 73
AssemblySolid_074 | STEP solid index 74
AssemblySolid_075 | STEP solid index 75
AssemblySolid_076 | STEP solid index 76
AssemblySolid_077 | STEP solid index 77
AssemblySolid_078 | STEP solid index 78
AssemblySolid_079 | STEP solid index 79
AssemblySolid_080 | STEP solid index 80
AssemblySolid_081 | STEP solid index 81
AssemblySolid_082 | STEP solid index 82
AssemblySolid_083 | STEP solid index 83
AssemblySolid_084 | STEP solid index 84
AssemblySolid_085 | STEP solid index 85
AssemblySolid_086 | STEP solid index 86
AssemblySolid_087 | STEP solid index 87
AssemblySolid_088 | STEP solid index 88
AssemblySolid_089 | STEP solid index 89
AssemblySolid_090 | STEP solid index 90
AssemblySolid_091 | STEP solid index 91
AssemblySolid_092 | STEP solid index 92
AssemblySolid_093 | STEP solid index 93
AssemblySolid_094 | STEP solid index 94
AssemblySolid_095 | STEP solid index 95
AssemblySolid_096 | STEP solid index 96
AssemblySolid_097 | STEP solid index 97
AssemblySolid_098 | STEP solid index 98
AssemblySolid_099 | STEP solid index 99
AssemblySolid_100 | STEP solid index 100
AssemblySolid_101 | STEP solid index 101
AssemblySolid_102 | STEP solid index 102
AssemblySolid_103 | STEP solid index 103
AssemblySolid_104 | STEP solid index 104
AssemblySolid_105 | STEP solid index 105
AssemblySolid_106 | STEP solid index 106
AssemblySolid_107 | STEP solid index 107
AssemblySolid_108 | STEP solid index 108
AssemblySolid_109 | STEP solid index 109
AssemblySolid_110 | STEP solid index 110
AssemblySolid_111 | STEP solid index 111
AssemblySolid_112 | STEP solid index 112
AssemblySolid_113 | STEP solid index 113
AssemblySolid_114 | STEP solid index 114
AssemblySolid_115 | STEP solid index 115
AssemblySolid_116 | STEP solid index 116
AssemblySolid_117 | STEP solid index 117
AssemblySolid_118 | STEP solid index 118
AssemblySolid_119 | STEP solid index 119
AssemblySolid_120 | STEP solid index 120
AssemblySolid_121 | STEP solid index 121
AssemblySolid_122 | STEP solid index 122
AssemblySolid_123 | STEP solid index 123
AssemblySolid_124 | STEP solid index 124
AssemblySolid_125 | STEP solid index 125
AssemblySolid_126 | STEP solid index 126
AssemblySolid_127 | STEP solid index 127
AssemblySolid_128 | STEP solid index 128
AssemblySolid_129 | STEP solid index 129
AssemblySolid_130 | STEP solid index 130
AssemblySolid_131 | STEP solid index 131
AssemblySolid_132 | STEP solid index 132
AssemblySolid_133 | STEP solid index 133
AssemblySolid_134 | STEP solid index 134
AssemblySolid_135 | STEP solid index 135
AssemblySolid_136 | STEP solid index 136
AssemblySolid_137 | STEP solid index 137
AssemblySolid_138 | STEP solid index 138
AssemblySolid_139 | STEP solid index 139
AssemblySolid_140 | STEP solid index 140
AssemblySolid_141 | STEP solid index 141
AssemblySolid_142 | STEP solid index 142
AssemblySolid_143 | STEP solid index 143
AssemblySolid_144 | STEP solid index 144
AssemblySolid_145 | STEP solid index 145
AssemblySolid_146 | STEP solid index 146
AssemblySolid_147 | STEP solid index 147
AssemblySolid_148 | STEP solid index 148
AssemblySolid_149 | STEP solid index 149
AssemblySolid_150 | STEP solid index 150
AssemblySolid_151 | STEP solid index 151
AssemblySolid_152 | STEP solid index 152
AssemblySolid_153 | STEP solid index 153
AssemblySolid_154 | STEP solid index 154

# IfcElementAssembly: Source-native physical solid occurrences, D1 nominal design reference DEV01
In: Reference coordinates
Description: Nominal design reference; manufacturing tolerances, material grades and ground-specific fixings not established; PredefinedType: USERDEFINED
