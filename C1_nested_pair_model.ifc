Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
Time: 2026-10-17T07:30:28
Written by: IfcOpenShell 0.8.0
Made in: IfcOpenShell 0.8.0

# IfcBuildingElementProxy: Physical source occurrence (8)
In: Reference coordinates
PredefinedType: USERDEFINED
Name | Description
NestedBlackBase_occurrence_01 | STEP solid index 0
NestedOrangeHollowBody_occurrence_01 | STEP solid index 1
NestedWhiteFilm1_occurrence_01 | STEP solid index 2
NestedWhiteFilm2_occurrence_01 | STEP solid index 3
NestedBlackBase_occurrence_02 | STEP solid index 4
NestedOrangeHollowBody_occurrence_02 | STEP solid index 5
NestedWhiteFilm1_occurrence_02 | STEP solid index 6
NestedWhiteFilm2_occurrence_02 | STEP solid index 7

# IfcElementAssembly: Source-native physical solid occurrences, C1_nested_pair nominal design reference DEV01
In: Reference coordinates
Description: Nominal design reference; manufacturing tolerances, material grades and ground-specific fixings not established; PredefinedType: USERDEFINED
