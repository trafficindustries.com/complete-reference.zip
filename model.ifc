Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: model.ifc
Time: 2026-10-17T00:00:00
Author: Traffic Industries
Organization: Traffic Industries
Written by: ifcopenshell 0.8.4
Made in: source-preserving parking reference export

# IfcBuildingElementProxy: Native final physical object (3)
In: TI-E1-WS900-P01
Description: Final source object; no hidden feature bodies exported; PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-E1-WS900-P01; SourceNativeSHA256: e08dd8b4e4abfb33e9a60122f8ae2e77510a2ac7b0d6e42357664f7554768598; SourceStepSHA256: 278255aa5c807bb1d246998a2e4ad8edb1f37675a4b1e0bcf797a736ccff84c2; Units: mm; ReferenceStatus: P01 proposed reference; independent QA and product acceptance pending; Appearance: Neutral reference shading; no approved appearance/material claim; ManufacturingBoundary: Reference geometry only; manufacturing tolerances and material properties not established
Name
Body
Film_front
Film_rear

# IfcElementAssembly: Source-linked product reference, TI-E1-WS900-P01
In: TI-E1-WS900-P01
Description: P01 proposed reference; independent QA and product acceptance pending; PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-E1-WS900-P01; SourceNativeSHA256: e08dd8b4e4abfb33e9a60122f8ae2e77510a2ac7b0d6e42357664f7554768598; SourceStepSHA256: 278255aa5c807bb1d246998a2e4ad8edb1f37675a4b1e0bcf797a736ccff84c2; Units: mm; ReferenceStatus: P01 proposed reference; independent QA and product acceptance pending; Appearance: Neutral reference shading; no approved appearance/material claim; ManufacturingBoundary: Reference geometry only; manufacturing tolerances and material properties not established
