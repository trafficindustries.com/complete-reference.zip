Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
Time: 2026-10-17T07:05:04
Written by: IfcOpenShell 0.8.0
Made in: IfcOpenShell 0.8.0

# IfcBuildingElementProxy: Source-native physical occurrence (4)
In: Product reference coordinates
PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-A2-FD750-DEV01; Revision: DEV01; SourceNativeSHA256: 40a1138d5d8a9c43c25e7ee42156f3de41958fd655ff65adc10d2c4feb64fd09; PhysicalOccurrences: 4; LengthUnit: mm; UseBoundary: Nominal design reference; manufacturing tolerances, material grades and ground-specific fixings not established; ManufacturingApproval: NOT_ESTABLISHED; Appearance: Neutral reference shading; material and colour supply not established
Name | Description
BlackBase | Physical solid Seat2
OrangePost | Physical solid BandRecess2
Film1 | Physical solid BandRing1
Film2 | Physical solid BandRing2

# IfcElementAssembly: Source-native physical occurrence assembly, TI-A2-FD750-DEV01 nominal design reference DEV01
In: Product reference coordinates
Description: Nominal design reference; material grades, manufacturing tolerances and ground-specific fixings are not established; PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-A2-FD750-DEV01; Revision: DEV01; SourceNativeSHA256: 40a1138d5d8a9c43c25e7ee42156f3de41958fd655ff65adc10d2c4feb64fd09; PhysicalOccurrences: 4; LengthUnit: mm; UseBoundary: Nominal design reference; manufacturing tolerances, material grades and ground-specific fixings not established; ManufacturingApproval: NOT_ESTABLISHED; Appearance: Neutral reference shading; material and colour supply not established
