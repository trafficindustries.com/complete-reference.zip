Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: model.ifc
Time: 2026-10-17T00:00:00
Author: Traffic Industries
Organization: Traffic Industries
Written by: IfcOpenShell 0.8.4
Made in: Source-preserving P01 reference export

# IfcProject, Traffic Industries reference CAD
Description: Local source-preserving facility product CAD formats

# IfcBuildingElementProxy: Source-native physical occurrence (7)
In: TI-H1-RB220-600-P01 reference coordinates
PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-H1-RB220-600-P01; ProductGroup: H1 rising bollards; SourceRevision: P01; SourceNativeSHA256: 3f978acf6192f9a9ca5bd5ee580ebb6a15293282f3c95da15a85abde39487b2c; PhysicalOccurrences: 7; LengthUnit: mm; SourcePDFRevision: Current site PDF is separately identified in product source-reference; see its stated relation and limits.; UseBoundary: Nominal source geometry reference only; no manufacturing tolerance, material, load, electrical, hydraulic, or installed-configuration approval.
Name | Description
FloorDrain | Measured native object FloorDrain
GuideFlange | Measured native object GuideFlange
GroundFrame | Measured native object GroundFrame
LEDMovingRecess | Measured native object LEDMovingRecess
MovingCap | Measured native object MovingCap
ReflectiveBand | Measured native object ReflectiveBand
LEDBand | Measured native object LEDBand

# IfcElementAssembly: Source-native physical occurrence assembly, TI-H1-RB220-600-P01 P01 nominal source reference
In: TI-H1-RB220-600-P01 reference coordinates
Description: P01 source geometry reference; not a fabrication release or approved material/load specification; PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-H1-RB220-600-P01; ProductGroup: H1 rising bollards; SourceRevision: P01; SourceNativeSHA256: 3f978acf6192f9a9ca5bd5ee580ebb6a15293282f3c95da15a85abde39487b2c; PhysicalOccurrences: 7; LengthUnit: mm; SourcePDFRevision: Current site PDF is separately identified in product source-reference; see its stated relation and limits.; UseBoundary: Nominal source geometry reference only; no manufacturing tolerance, material, load, electrical, hydraulic, or installed-configuration approval.
