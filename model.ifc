Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: model.ifc
Time: 2026-10-17T00:00:00
Author: Traffic Industries
Organization: Traffic Industries
Written by: IfcOpenShell 0.8.4
Made in: Source-preserving P01 reference export

# IfcProject, Traffic Industries reference CAD
Description: Local source-preserving facility product CAD formats

# IfcBuildingElementProxy: Source-native physical occurrence (19)
In: TI-F1-SWL160-P01 reference coordinates
PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-F1-SWL160-P01; ProductGroup: F1 solar warning lamps; SourceRevision: P01; SourceNativeSHA256: 976daf4c5c0eb932cea265a0251efcffe21c26575d743371b8d828bdd3666bb1; PhysicalOccurrences: 19; LengthUnit: mm; SourcePDFRevision: Current site PDF is separately identified in product source-reference; see its stated relation and limits.; UseBoundary: Nominal source geometry reference only; no manufacturing tolerance, material, load, electrical, hydraulic, or installed-configuration approval.
Name | Description
SwitchOpening | Measured native object SwitchOpening
Switch | Measured native object Switch
Spigot | Measured native object Spigot
BatteryEnvelope | Measured native object BatteryEnvelope
SolarFrame | Measured native object SolarFrame
ActiveSolarPanel | Measured native object ActiveSolarPanel
AdapterClampBore1 | Measured native object AdapterClampBore1
RailSpacer | Measured native object RailSpacer
SpigotNut | Measured native object SpigotNut
LensRingM1 | Measured native object LensRingM1
AmberLensM1 | Measured native object AmberLensM1
LensRing1 | Measured native object LensRing1
AmberLens1 | Measured native object AmberLens1
SolarSupport0 | Measured native object SolarSupport0
SolarSupport1 | Measured native object SolarSupport1
RailPadM1 | Measured native object RailPadM1
RailPad1 | Measured native object RailPad1
ClampScrewM1 | Measured native object ClampScrewM1
ClampScrew1 | Measured native object ClampScrew1

# IfcElementAssembly: Source-native physical occurrence assembly, TI-F1-SWL160-P01 P01 nominal source reference
In: TI-F1-SWL160-P01 reference coordinates
Description: P01 source geometry reference; not a fabrication release or approved material/load specification; PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-F1-SWL160-P01; ProductGroup: F1 solar warning lamps; SourceRevision: P01; SourceNativeSHA256: 976daf4c5c0eb932cea265a0251efcffe21c26575d743371b8d828bdd3666bb1; PhysicalOccurrences: 19; LengthUnit: mm; SourcePDFRevision: Current site PDF is separately identified in product source-reference; see its stated relation and limits.; UseBoundary: Nominal source geometry reference only; no manufacturing tolerance, material, load, electrical, hydraulic, or installed-configuration approval.
