Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: model.ifc
Time: 2026-10-17T00:00:00
Author: Traffic Industries
Organization: Traffic Industries
Written by: IfcOpenShell 0.8.4
Made in: Source-preserving P01 reference export

# IfcProject, Traffic Industries reference CAD
Description: Local source-preserving facility product CAD formats

# IfcBuildingElementProxy: Source-native physical occurrence (15)
In: TI-TS-B14A-P01 reference coordinates
PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-TS-B14A-P01; ProductGroup: B3 traffic signs; SourceRevision: P01; SourceNativeSHA256: d1849c964b6f0842483b72a3657f35c9f2e5aed53aace79a20d37ee72abcea78; PhysicalOccurrences: 15; LengthUnit: mm; SourcePDFRevision: Current site PDF is separately identified in product source-reference; see its stated relation and limits.; UseBoundary: Nominal source geometry reference only; no manufacturing tolerance, material, load, electrical, hydraulic, or installed-configuration approval.
Name | Description
SignBlank | Measured native object SignBlank
PostTube | Measured native object PostTube
FoundationSocket | Measured native object FoundationSocket
WeldStud00 | Measured native object WeldStud00
WeldStud01 | Measured native object WeldStud01
ClampBolt00 | Measured native object ClampBolt00
ClampBolt01 | Measured native object ClampBolt01
SlottedRail01 | Measured native object SlottedRail01
EarBore01 | Measured native object EarBore01
WeldStud10 | Measured native object WeldStud10
WeldStud11 | Measured native object WeldStud11
ClampBolt10 | Measured native object ClampBolt10
ClampBolt11 | Measured native object ClampBolt11
SlottedRail11 | Measured native object SlottedRail11
EarBore11 | Measured native object EarBore11

# IfcElementAssembly: Source-native physical occurrence assembly, TI-TS-B14A-P01 P01 nominal source reference
In: TI-TS-B14A-P01 reference coordinates
Description: P01 source geometry reference; not a fabrication release or approved material/load specification; PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-TS-B14A-P01; ProductGroup: B3 traffic signs; SourceRevision: P01; SourceNativeSHA256: d1849c964b6f0842483b72a3657f35c9f2e5aed53aace79a20d37ee72abcea78; PhysicalOccurrences: 15; LengthUnit: mm; SourcePDFRevision: Current site PDF is separately identified in product source-reference; see its stated relation and limits.; UseBoundary: Nominal source geometry reference only; no manufacturing tolerance, material, load, electrical, hydraulic, or installed-configuration approval.
