Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
Time: 2026-10-17T07:05:15
Written by: IfcOpenShell 0.8.0
Made in: IfcOpenShell 0.8.0

# IfcBuildingElementProxy: Source-native physical occurrence (5)
In: Product reference coordinates
PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-A3-LC1000-DEV01; Revision: DEV01; SourceNativeSHA256: 94e6b9e1671a7e4dca04e85380898e8cb19d302354692fb6ec27f4c34d0cccd4; PhysicalOccurrences: 5; LengthUnit: mm; UseBoundary: Nominal design reference; manufacturing tolerances, material grades and ground-specific fixings not established; ManufacturingApproval: NOT_ESTABLISHED; Appearance: Neutral reference shading; material and colour supply not established
Name | Description
YellowBase | Physical solid Seat5
BlackMountPlate | Physical solid MountPlateSocket
OrangePost | Physical solid BandRecess2
Film1 | Physical solid BandRing1
Film2 | Physical solid BandRing2

# IfcElementAssembly: Source-native physical occurrence assembly, TI-A3-LC1000-DEV01 nominal design reference DEV01
In: Product reference coordinates
Description: Nominal design reference; material grades, manufacturing tolerances and ground-specific fixings are not established; PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-A3-LC1000-DEV01; Revision: DEV01; SourceNativeSHA256: 94e6b9e1671a7e4dca04e85380898e8cb19d302354692fb6ec27f4c34d0cccd4; PhysicalOccurrences: 5; LengthUnit: mm; UseBoundary: Nominal design reference; manufacturing tolerances, material grades and ground-specific fixings not established; ManufacturingApproval: NOT_ESTABLISHED; Appearance: Neutral reference shading; material and colour supply not established
