Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: model.ifc
Time: 2026-10-17T00:00:00
Author: Traffic Industries
Organization: Traffic Industries
Written by: ifcopenshell 0.8.4
Made in: source-preserving parking reference export

# IfcBuildingElementProxy: Native final physical object, WeldedBody
In: TI-E5-BF102-P01
Description: Final source object; no hidden feature bodies exported; PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-E5-BF102-P01; SourceNativeSHA256: 4ac0afb596c337c09405c0471ff125b29914c497dd0fc7d7bd6bd5654d32bfd5; SourceStepSHA256: 22591fc340d97388c220c9868d824108fa571ac599add98728a6b09702fb994f; Units: mm; ReferenceStatus: P01 proposed native reference; current site PDF R02 dimensions align, P01-to-R02 revision link unverified; manufacturing approval pending; Appearance: Neutral reference shading; no approved appearance/material claim; ManufacturingBoundary: Reference geometry only; manufacturing tolerances and material properties not established

# IfcElementAssembly: Source-linked product reference, TI-E5-BF102-P01
In: TI-E5-BF102-P01
Description: P01 proposed native reference; current site PDF R02 dimensions align, P01-to-R02 revision link unverified; manufacturing approval pending; PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-E5-BF102-P01; SourceNativeSHA256: 4ac0afb596c337c09405c0471ff125b29914c497dd0fc7d7bd6bd5654d32bfd5; SourceStepSHA256: 22591fc340d97388c220c9868d824108fa571ac599add98728a6b09702fb994f; Units: mm; ReferenceStatus: P01 proposed native reference; current site PDF R02 dimensions align, P01-to-R02 revision link unverified; manufacturing approval pending; Appearance: Neutral reference shading; no approved appearance/material claim; ManufacturingBoundary: Reference geometry only; manufacturing tolerances and material properties not established
