Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: model.ifc
Time: 2026-10-17T00:00:00
Author: Traffic Industries
Organization: Traffic Industries
Written by: ifcopenshell 0.8.4
Made in: source-preserving parking reference export

# IfcBuildingElementProxy: Native final physical object, AttentionTile
In: TI-E6-TW600-P01-ATTENTION
Description: Final source object; no hidden feature bodies exported; PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-E6-TW600-P01-ATTENTION; SourceNativeSHA256: 26440a597234bf94272a068f5c4eb8a1387023fb4b0fe2a0e917a0ff92e13d3c; SourceStepSHA256: e2d0a99f5eeb69e9b8c625f1c184f272c1097d92d7d4d5240513033d27b70ff4; Units: mm; ReferenceStatus: P01 proposed native reference; current site PDF R02 dimensions and 50-cone count align, P01-to-R02 revision link unverified; ISO conformity and manufacturing approval not established; Appearance: Neutral reference shading; no approved appearance/material claim; ManufacturingBoundary: Reference geometry only; manufacturing tolerances and material properties not established

# IfcElementAssembly: Source-linked product reference, TI-E6-TW600-P01-ATTENTION
In: TI-E6-TW600-P01-ATTENTION
Description: P01 proposed native reference; current site PDF R02 dimensions and 50-cone count align, P01-to-R02 revision link unverified; ISO conformity and manufacturing approval not established; PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-E6-TW600-P01-ATTENTION; SourceNativeSHA256: 26440a597234bf94272a068f5c4eb8a1387023fb4b0fe2a0e917a0ff92e13d3c; SourceStepSHA256: e2d0a99f5eeb69e9b8c625f1c184f272c1097d92d7d4d5240513033d27b70ff4; Units: mm; ReferenceStatus: P01 proposed native reference; current site PDF R02 dimensions and 50-cone count align, P01-to-R02 revision link unverified; ISO conformity and manufacturing approval not established; Appearance: Neutral reference shading; no approved appearance/material claim; ManufacturingBoundary: Reference geometry only; manufacturing tolerances and material properties not established
