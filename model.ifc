Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: model.ifc
Time: 2026-10-17T00:00:00
Author: Traffic Industries
Organization: Traffic Industries
Written by: IfcOpenShell 0.8.4
Made in: Source-preserving P01 reference export

# IfcProject, Traffic Industries reference CAD
Description: Local source-preserving facility product CAD formats

# IfcBuildingElementProxy: Source-native physical occurrence (8)
In: TI-TB-P01 reference coordinates
PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-TB-P01; ProductGroup: B1 traffic barriers; SourceRevision: P01; SourceNativeSHA256: 88370766266ab5c46b74e50c432f9c944b4795ee00e985cf9d4d4671a09f0214; PhysicalOccurrences: 8; LengthUnit: mm; SourcePDFRevision: Current site PDF is separately identified in product source-reference; see its stated relation and limits.; UseBoundary: Nominal source geometry reference only; no manufacturing tolerance, material, load, electrical, hydraulic, or installed-configuration approval.
Name | Description
FemaleBore1 | Measured native object FemaleBore1
FillCap | Measured native object FillCap
DrainPlug | Measured native object DrainPlug
JointPin | Measured native object JointPin
FilmM10 | Measured native object FilmM10
FilmM11 | Measured native object FilmM11
Film10 | Measured native object Film10
Film11 | Measured native object Film11

# IfcElementAssembly: Source-native physical occurrence assembly, TI-TB-P01 P01 nominal source reference
In: TI-TB-P01 reference coordinates
Description: P01 source geometry reference; not a fabrication release or approved material/load specification; PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-TB-P01; ProductGroup: B1 traffic barriers; SourceRevision: P01; SourceNativeSHA256: 88370766266ab5c46b74e50c432f9c944b4795ee00e985cf9d4d4671a09f0214; PhysicalOccurrences: 8; LengthUnit: mm; SourcePDFRevision: Current site PDF is separately identified in product source-reference; see its stated relation and limits.; UseBoundary: Nominal source geometry reference only; no manufacturing tolerance, material, load, electrical, hydraulic, or installed-configuration approval.
