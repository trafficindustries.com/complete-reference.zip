Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: model.ifc
Time: 2026-10-17T00:00:00
Author: Traffic Industries
Organization: Traffic Industries
Written by: ifcopenshell 0.8.4
Made in: B2 source-preserving nominal reference export

# IfcBuildingElementProxy: Source-native occurrence (35)
In: Product reference coordinates
PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-SB-P01; ProductGroup: B2 safety barricades; Revision: Accepted two-panel connection R2 (K-468/K-471); SourceNativeSHA256: 37f82a945c3e0dc8b5d91ae6a95285cc7a303209a6e73a2d563a7f21d773f282; NominalPhysicalOccurrences: 35; Unit: mm; UseBoundary: Nominal geometry reference only; manufacturing tolerances, pad/fastener specifications, physical retention and loads remain unestablished; Retainer: Exact GN retainer shape unavailable; conservative envelope remains only in native reference context, excluded from physical occurrence export; Appearance: Neutral reference shading; no approved colour/material claim
Name | Description
TongueBore1_P1 | TongueBore1 — exact source BRep copy
FootBore0_P1 | FootBore0 — exact source BRep copy
FootBore1_P1 | FootBore1 — exact source BRep copy
PivotPin0_P1 | PivotPin0 — exact source BRep copy
PivotPin1_P1 | PivotPin1 — exact source BRep copy
ReflectiveFilmM1_P1 | ReflectiveFilmM1 — exact source BRep copy
ReflectiveFilm1_P1 | ReflectiveFilm1 — exact source BRep copy
TongueBore1_P2 | TongueBore1 — exact source BRep translated +1670.0 X
FootBore0_P2 | FootBore0 — exact source BRep translated +1670.0 X
FootBore1_P2 | FootBore1 — exact source BRep translated +1670.0 X
PivotPin0_P2 | PivotPin0 — exact source BRep translated +1670.0 X
PivotPin1_P2 | PivotPin1 — exact source BRep translated +1670.0 X
ReflectiveFilmM1_P2 | ReflectiveFilmM1 — exact source BRep translated +1670.0 X
ReflectiveFilm1_P2 | ReflectiveFilm1 — exact source BRep translated +1670.0 X
Adapter1FrontHalf | Adapter 1 front (+Y) half + lower lug
Adapter1RearHalf | Adapter 1 rear (-Y) half
Adapter2MinusYHalf | Adapter 2 mirrored -Y half + upper lug
Adapter2PlusYHalf | Adapter 2 mirrored +Y half
Adapter1Pad_Xminus | Adapter 1 — root proposal, front lug on +Y half / Pad_Xminus (0.5 mm proposal)
Adapter1Pad_Xplus | Adapter 1 — root proposal, front lug on +Y half / Pad_Xplus (0.5 mm proposal)
Adapter1Pad_Yminus | Adapter 1 — root proposal, front lug on +Y half / Pad_Yminus (0.5 mm proposal)
Adapter1Pad_Yplus | Adapter 1 — root proposal, front lug on +Y half / Pad_Yplus (0.5 mm proposal)
Adapter2Pad_Xminus | Adapter 2 — root proposal, mirrored; lug z +12 mm / Pad_Xminus (0.5 mm proposal)
Adapter2Pad_Xplus | Adapter 2 — root proposal, mirrored; lug z +12 mm / Pad_Xplus (0.5 mm proposal)
Adapter2Pad_Yminus | Adapter 2 — root proposal, mirrored; lug z +12 mm / Pad_Yminus (0.5 mm proposal)
Adapter2Pad_Yplus | Adapter 2 — root proposal, mirrored; lug z +12 mm / Pad_Yplus (0.5 mm proposal)
M6_A1_1540_793 | M6 nominal hardware envelope at X=1540.0 Z=793.0 (proposal)
M6_A1_1540_823 | M6 nominal hardware envelope at X=1540.0 Z=823.0 (proposal)
M6_A1_1610_793 | M6 nominal hardware envelope at X=1610.0 Z=793.0 (proposal)
M6_A1_1610_823 | M6 nominal hardware envelope at X=1610.0 Z=823.0 (proposal)
M6_A2_1660_793 | M6 nominal hardware envelope at X=1660.0 Z=793.0 (proposal)
M6_A2_1660_823 | M6 nominal hardware envelope at X=1660.0 Z=823.0 (proposal)
M6_A2_1730_793 | M6 nominal hardware envelope at X=1730.0 Z=793.0 (proposal)
M6_A2_1730_823 | M6 nominal hardware envelope at X=1730.0 Z=823.0 (proposal)
ConnectionPin | Connection pin — Spreadsheet-driven root proposal

# IfcElementAssembly: Two source panels and nominal split-clamp connection, B2 / TI-SB-P01 nominal two-panel R2
In: Product reference coordinates
Description: Accepted nominal geometry K-468/K-471; no manufacturing fit, physical retention or load approval; PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-SB-P01; ProductGroup: B2 safety barricades; Revision: Accepted two-panel connection R2 (K-468/K-471); SourceNativeSHA256: 37f82a945c3e0dc8b5d91ae6a95285cc7a303209a6e73a2d563a7f21d773f282; NominalPhysicalOccurrences: 35; Unit: mm; UseBoundary: Nominal geometry reference only; manufacturing tolerances, pad/fastener specifications, physical retention and loads remain unestablished; Retainer: Exact GN retainer shape unavailable; conservative envelope remains only in native reference context, excluded from physical occurrence export; Appearance: Neutral reference shading; no approved colour/material claim
