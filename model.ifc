Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: model.ifc
Time: 2026-10-17T00:00:00
Author: Traffic Industries
Organization: Traffic Industries
Written by: ifcopenshell 0.8.4
Made in: source-preserving parking reference export

# IfcBuildingElementProxy: Native final physical object, GuidingTile
In: TI-E6-TW600-P01-GUIDING
Description: Final source object; no hidden feature bodies exported; PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-E6-TW600-P01-GUIDING; SourceNativeSHA256: 53157c3a973159032d34ebdfed73af778c7e49d11ee809a9f247c8ab761874f8; SourceStepSHA256: 4ecb8a0004c373446f195ca3722c95f00cfc22a2a902256295aa77699662775b; Units: mm; ReferenceStatus: P01 proposed native reference; current site PDF R02 dimensions align, P01-to-R02 revision link unverified; ISO conformity and manufacturing approval not established; Appearance: Neutral reference shading; no approved appearance/material claim; ManufacturingBoundary: Reference geometry only; manufacturing tolerances and material properties not established

# IfcElementAssembly: Source-linked product reference, TI-E6-TW600-P01-GUIDING
In: TI-E6-TW600-P01-GUIDING
Description: P01 proposed native reference; current site PDF R02 dimensions align, P01-to-R02 revision link unverified; ISO conformity and manufacturing approval not established; PredefinedType: USERDEFINED
Pset_TI_ProductReference - ProductCode: TI-E6-TW600-P01-GUIDING; SourceNativeSHA256: 53157c3a973159032d34ebdfed73af778c7e49d11ee809a9f247c8ab761874f8; SourceStepSHA256: 4ecb8a0004c373446f195ca3722c95f00cfc22a2a902256295aa77699662775b; Units: mm; ReferenceStatus: P01 proposed native reference; current site PDF R02 dimensions align, P01-to-R02 revision link unverified; ISO conformity and manufacturing approval not established; Appearance: Neutral reference shading; no approved appearance/material claim; ManufacturingBoundary: Reference geometry only; manufacturing tolerances and material properties not established
